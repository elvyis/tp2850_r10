# Keil uVision project TP2850_MCU.uvproj, settings and files
target Target 1 (MCS-51)
  device: N78E517A Nuvoton
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM=(0x-0xFFFF) CLOCK(40000000)
  output: TP2850_2825B +hex
  AfterMake: hex2bin obj/tp2850_2825B.bin obj/tp2850_2825B.hex
  c flags: Optimize=9
  group Source Group 1
    ./src/: I2c.c Main.c Printf.c crc16.c TP2825B.c
    ./src/MDIN3xx/: mdin3xx.c mdincoef.c mdindly.c mdinfrmt.c mdinhtx.c mdini2c.c mdinipc.c app340.c mdinaux.c
